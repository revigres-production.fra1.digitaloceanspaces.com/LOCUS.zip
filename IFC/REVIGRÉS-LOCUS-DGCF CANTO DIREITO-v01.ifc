Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-06-20T12:36:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 20 12:36:23 2025 * Host: STB002 * Database: C:\Users\LARISS~1\AppData\Local\Temp\234e31d9-e186-458c-9206-d387dea7a233\71eadb94-b9ed-4f9a-babf-7656bed83545\ifc * Database version: 5507 * Database creation date: Fri Jun 20 12:36:23 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 20 12:36:23 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 20 12:36:23 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-ALLOY, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-ALLOY:281912
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SILK-ALLOY
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SILK-LOCUS ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoBS7976: -; ResistenciaAoDeslizamentoBS7976: -; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SILK-ALLOY
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-ALLOY

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-BONE, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-BONE:282186
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SILK-BONE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SILK-LOCUS BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoBS7976: -; ResistenciaAoDeslizamentoBS7976: -; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SILK-BONE
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-BONE
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-BONE
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-BONE
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-BONE
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-BONE

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-GRIS, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-GRIS:282622
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SILK-GRIS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SILK-LOCUS GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoBS7976: -; ResistenciaAoDeslizamentoBS7976: -; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SILK-GRIS
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-GRIS
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-GRIS
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-GRIS
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-GRIS
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-GRIS

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-SMOG, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SILK-SMOG:282629
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SILK-SMOG
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SILK-LOCUS SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoBS7976: -; ResistenciaAoDeslizamentoBS7976: -; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SILK-SMOG
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SILK-SMOG

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-ALLOY, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-ALLOY:282039
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-ALLOY
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SOFT GRIP -LOCUS ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SOFT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx ± 1.0 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: > 36; ResistenciaAoDeslizamentoBS7976: > 36; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-ALLOY

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-BONE, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-BONE:282187
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-BONE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SOFT GRIP -LOCUS BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SOFT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx ± 1.0 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: > 36; ResistenciaAoDeslizamentoBS7976: > 36; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-BONE
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-BONE
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-BONE
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-BONE
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-BONE
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-BONE

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-GRIS, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-GRIS:282623
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-GRIS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SOFT GRIP -LOCUS GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SOFT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx ± 1.0 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: > 36; ResistenciaAoDeslizamentoBS7976: > 36; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-GRIS
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-GRIS
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-GRIS
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-GRIS
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-GRIS
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-GRIS

# IfcCovering: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-SMOG, REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01:30X60-SOFT GRIP-SMOG:282630
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 8.5 mm; Finish: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-SMOG
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRÉS-LOCUS-DG CF CANTO DIREITO-30x60 cm-SOFT GRIP -LOCUS SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Locus; Acabamento: SOFT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/locus; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx ± 1.0 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: > 36; ResistenciaAoDeslizamentoBS7976: > 36; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Material: REVIGRÉS-LOCUS-30X60-DGCF-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-LOCUS-DGCF CANTO DIREITO-R21-v01: 30X60-SOFT GRIP-SMOG
